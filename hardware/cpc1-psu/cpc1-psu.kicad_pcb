# Repository nbolton/amiga

## KiCad design hardware/a1200-psu/a1200-psu.kicad_pcb

File hardware/a1200-psu/readme.md:

# Amiga 1200 PSU (Power Supply Unit)

- PCB P-No: 30501-001 A
- PSU P-No: 391029-02
- Rating: UK 220-240 V 300 mA

**TODO:** Update README to reflect PR https://github.com/nbolton/amiga/pull/2 (thanks @ChewChewie)

This A1200 schematic is based on A500 PSU schematic by Greg McCarthy (https://github.com/StormTrooper)

Original A500 PSU schematic: https://github.com/baldengineer/bit-preserve/tree/master/Amiga/A500.PSU.312503-03

Parts:
C1, C4: 10nF; C_Rect_L7.0mm_W2.5mm_P5.00mm
C2, C3, C7, C8: 4n7; C_Rect_L11.0mm_W2.8mm_P10.00mm_MKT
C5, C6: 220nF; C_Rect_L28.0mm_W8.0mm_P22.50mm_MKS4
C9: 220pF; C_Disc_D6.0mm_W2.5mm_P5.00mm
C10: 10n; C_Disc_D9.0mm_W5.0mm_P10.00mm
C11: 33uF; C_Radial_D16.0mm_H31.5mm_P7.50mm; Rating 400V
C12: 47uF; CP_Radial_D6.3mm_P2.50mm; Rating 35V
C13: 82uF; CP_Radial_D4.0mm_P1.50mm
C14: 220uF; CP_Radial_D5.0mm_P2.50mm
C15, C18: 1000uF; CP_Radial_D8.0mm_P5.00mm
C16, C17: 47uF; CP_Radial_D4.0mm_P1.50mm
C19: 1uF; CP_Radial_D4.0mm_P1.50mm
C20: 1nF; C_Rect_L7.0mm_W2.5mm_P5.00mm
C21: 470pF; C_Rect_L7.0mm_W4.5mm_P5.00mm
D1: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
D2: 1N4742A; D_DO-35_SOD27_P10.16mm_Horizontal
D3: BYV26E; D_DO-41_SOD81_P7.62mm_Horizontal
D4: 1N4007; Diode_Bridge
D5: 1N4935; D_DO-41_SOD81_P10.16mm_Horizontal
D6: 1N5230B; D_DO-35_SOD27_P10.16mm_Horizontal
D7: 1N54xx; D_5W_P12.70mm_Horizontal
D8: MR852; D_5W_P12.70mm_Horizontal
D9, D10: MR852; Diode_Heatsink
D11: Yellow; LED_D3.0mm
F1: 250V T 1A; Fuseholder_Cylinder-5x20mm_Schurter_0031_8201_Horizontal_Op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
J1: AC-In; TerminalBlock_Phoenix_PT-1,5-3-3.5-H_1x03_P3.50mm_Horizontal
J2: DC-Out; TerminalBlock_Phoenix_MPT-0,5-5-2.54_1x05_P2.54mm_Horizontal
J3: Conn_01x02; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
L1: 47mH; Filter_FILTERCON_1FPxx
L2, L3, L4: L_Small; L_Radial_D6.0mm_P4.00mm
Q1: P2N60; TO-220-3_Vertical_Staggered
R1: 680R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 240k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 25k5; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 821k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R5: 68k; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R6: 460R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7: 150R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R8: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9: 1R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R10: 100k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R11: 10R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R12: 47R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R13: ?; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R14, R15, R16: ?; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R17: 330R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R18: 500k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: Inline
TH1: 30R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
TR1: A1200-PSU-TR; Transformer
U1: UC3844_DIP8; DIP-8_W7.62mm
U2: PC817; DIP-4_W7.62mm
U3: TL431D; TO-92_Wide

Connections:
+5V: C18.1, J2.1 (Red), L4.2, R13.2, R14.2, R15.2, U2.1
+12V: C17.1, J2.2 (Brown), L3.2
+330V: C10.1, C11.1, D4.1 (+), R4.1, R10.1, R18.2, TR1.1
-12V: C16.2, J2.3 (White), L2.2, R17.2
/Live_Pre_LF: C5.1, D1.2 (A), L1.3, TH1.2
/TR1_P5: R11.2, TR1.5
/TR_5V: D9.2 (A), D10.2 (A), TR1.12
Earth: C2.2, C7.2, C8.2, J1.3 (E), J2.5 (Yellow), J3.2
GND: C13.1, C14.2, C15.2, C16.1, C17.2, C18.2, D6.2 (A), J2.4 (Black), J3.1, R16.1, R17.1, TR1.8, TR1.9, U3.2 (A)
GNDD: C1.1, C3.1, C11.2, C12.2, C20.1, C21.2, D2.2 (A), D4.2 (-), D11.1 (K), R8.2, R9.2, TR1.6, U1.2 (FB), U1.5 (GND), U2.3
unnamed: C2.1, C3.2
unnamed: C6.1, C7.1, D4.4, L1.4
unnamed: C6.2, C8.1, D4.3, L1.2
unnamed: D1.1 (K), R5.2
unnamed: C9.1, D2.1 (K), Q1.3 (S), R6.2, R9.1
unnamed: C9.2, D3.2 (A), Q1.2 (D), TR1.3
unnamed: C10.2, D3.1 (K), R10.2
unnamed: D5.2 (A), R11.1
unnamed: C12.1, D5.1 (K), R5.1, U1.7 (VCC)
unnamed: D6.1 (K), R12.1, R13.1, U2.2
unnamed: C13.2, D7.2 (A), L2.1
unnamed: D7.1 (K), TR1.7
unnamed: D8.2 (A), TR1.10
unnamed: C14.1, D8.1 (K), L3.1
unnamed: C15.1, D9.1 (K), D10.1 (K), L4.1, TR1.11
unnamed: D11.2 (A), R18.1
unnamed: F1.1, TH1.1
unnamed: F1.2, J1.1 (L), SW1.2 (B)
unnamed: C5.2, J1.2 (N), L1.1
unnamed: Q1.1 (G), R7.1, R8.1
unnamed: C1.2, C4.1, R1.1, U1.1 (COMP), U2.4
unnamed: C21.1, R4.2, R6.1, U1.3 (CS)
unnamed: R7.2, U1.6 (OUT)
unnamed: C4.2, C20.2, R2.2, R3.2, U1.4 (RC)
unnamed: R1.2, R2.1, R3.1, U1.8 (VREF)
unnamed: C19.1, R12.2, U3.3 (K)
unnamed: C19.2, R14.1, R15.1, R16.2, U3.1 (REF)

Notes on the sheet:
Safety LED (optional)
Test of known good working UC3844 PWM IC Pin 6 (OUT) - Load on 5V output I (5 V) | Duty | Period | V max ---- | ----- | ---- | ---- 0 mA | 7.0% | 276 ms | 18.0 V 28 mA | 4.0% | 25 us | 12.2 V 1.0 A | 9.5% | 25 us | 14.8 V 3.0 A | 15.0% | 25 us | 16.4 V 6.0 A | 20.0% | 25 us | 19.0 V
Test of known good working PSU AC current measurements under load Tested on 240 VAC with dim bulb limiter Ticking sound under no load is normal 5 VDC | 12 VDC | 240 VAC ---- | ---- | ---- 0.00 A 4.90 V | 0 mA 16.00 V | 31 mA 0.00 A 5.10 V | 70 mA 10.96 V | 37 mA 1.00 A 4.99 V | 70 mA 11.89 V | 68 m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
Main cap 400ms to charge to 334 V 1.2s to discharge to 18 V
100uF OK
P2N60 alternatives GDS 600 V 2.9 A 70 W RDS(on) < 3.5 ohm Vgs +/- 20 V STP4NK60Z (4 A) STP5NK60Z (5 A) IRFBC30PBF (3.6A)
Warning: Exceeding capacitance will pop FET.
RT/CT
Works without Z ¯\_(ツ)_/¯
16 V
TR1_P5 Vmax 30 V Vpp 100 V Freq 43 kHz
1N5242B OK?
AC/DC line voltage
BZX55 OK
DC stepped down
100R OK
340 V
470R OK
PWM 39kHz
330V BFC charge indicator
1M OK
Full load voltage test Output | Load | Voltage -- | -- | -- +5 V | 3 A | +4.67V +12 V | 493 mA | +11.68 V -12 V | 92 mA | -12.76 V AC draws 240 mA at 240 V
RC 70kHz
Line filter

Board: 2 copper layers, 147.0 x 76.0 mm, 64 parts (0 on the bottom side), 37 nets.

## Commit log

2023-02-08 A500 PSU from baldengineer/bit-preserve
2023-02-08 Cloned A500 PSU as A1200 PSU
2023-02-08 Credit to Greg McCarthy
2023-02-08 Add NTC and LF caps
2023-02-08 Set TH value and annotate
2023-02-08 Matched transformer to A1200
    Also:
    - Segmented board into line/low
    - Removed A500 diodes on 5V
    - Added some TODOs
2023-02-08 Exported to PDF/PNG
2023-02-09 Rename A500 lib
2023-02-09 Started on P2N60 + UC3844_DIP8
2023-02-09 Reorganised line side
    Also made some corrections for stepped down side
2023-02-10 Convert A500 PDF to PNG
2023-02-10 Fix bug in batch script
2023-02-10 Convert A1200 PDF to PNG
2023-02-10 Add PNG for those who don't have KiCad handy
2023-02-10 Fixed transformer wiring
    Also corrected cap values
2023-02-10 Removed TR1 todo
2023-02-10 Remove email
2023-02-10 Reorganised step down side
2023-02-10 Fixed R values and added to PCB
2023-02-10 Add transformer footprint
2023-02-10 Changed TR model
2023-02-10 Update PDF/PNG
2023-02-10 Increased pixel density
2023-02-10 Add more components to PCB
2023-02-11 Finished PCB and add missing parts
2023-02-11 Replace pin headers with terminals
2023-02-11 Fixed various PCB layout errors
    Also fixed:
    - R value
    - Live/PWM IC connection
2023-02-11 Generated PNGs
2023-02-11 Upscaled PNGs
2023-02-11 Reduced scale of schematic PNG
2023-02-11 Front and back photos
2023-02-11 Reduced size of back photo
2023-02-11 Create fp-info-cache
2023-02-11 Fixed bridge footprint
2023-02-11 Add fp-info-cache
2023-02-11 Fixed ERC/DRC errors
2023-02-11 Exported PNGs for 1F/1C
2023-02-11 Add front and back
2023-02-11 Started on filled zones
2023-02-13 Remove cache file
2023-02-13 Update 3D model pos
    Also add jumper from original; not required for circuit but helps to understand the original board
2023-02-13 Add warning for UC3844 pin 3 cap
2023-02-21 Reorganised PWM IC power supply
    Also discovered some new part values
2023-02-22 Add testing notes
2023-02-24 Add connector image
2023-04-18 Rotate board back photo to original
2023-04-18 Short GND-Earth and fixed -12 connection
2023-04-20 Short GND-Earth and fixed -12 connection (#2)
2023-08-14 Commodore PC-1 PSU schematic
2023-08-14 Pretty pictures for CPC1 PSU
2023-08-19 Fixed C3/C4 values
    2200 uF! Doh!
2023-08-19 Fixed C6 and C5 values
2023-08-19 Changed part number
2023-08-19 Change component (longer life)
